# Keil uVision project smallprotect.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smallprotect
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,ARM_MATH_MATRIX_CHECK,ARM_MATH_CM3 ,ARM_MATH_ROUNDING
  c include: ..\Libraries\FWLib\inc;..\User;..\Libraries\CMSIS;..\User\MyGui\include;..\User\MyGui\Driver\160_160;..\User\userProgram\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group FWLIB
    ../Libraries/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c systemconfig.c
    ../User/userProgram/source/: keyDriver.c menutest.c
  group Gui
    ../User/MyGui/source/: lkdGuiBasic.c lkdGuiColour.c lkdGuiFont.c lkdGuiPublic.c lkdGuiControl.c lkdGuiWin.c lkdGuiMenu.c
    ../User/MyGui/Driver/160_160/: lkdGuiDriver.c UC1698Driver.c zikuSpi.c lkdmyFont.c GT21L16S2W_lib.lib
